# Keil uVision project TEST522.uvproj, settings and files
target 射频读写卡器 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TEST522 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 主程序
    ./: MAIN.C RC522.C 5110-51.c
